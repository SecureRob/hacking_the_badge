# Repository SecureRob/hacking_the_badge

## KiCad design hw/KiCad_badge/the_badge/the_badge.kicad_pcb

Parts:
BT1: 36-596-ND; BAT_596; PARTREV D; Digikey 36-596-ND
BT2: 36-590-ND; BAT_590; PARTREV E; Digikey 36-590-ND
BT3: AAA; BatteryHolder_Keystone_2466_1xAAA
C1, C2, C3, C4, C5: 10uF; C_0603_1608Metric; Digikey 587-5869-1-ND
C6, C11, C14, C15, C16: 100nF; C_0603_1608Metric; Digikey 311-1088-1-ND
C7, C13: 1uF; C_0603_1608Metric; Digikey 311-1446-1-ND
C9, C12: 16pF; C_0603_1608Metric; Digikey 311-3964-1-ND
CON1, CON2: PPTC081LFBN-RC; MIKROBUS_HOST_CONN
D1, D2, D7, D8, D13, D14: 732-4971-1-ND; LED_0603_1608Metric; Digikey 732-4971-1-ND
D3, D5: D_Schottky; D_SOD-523; Digikey RB520S30T1GOSCT-ND
D4: IR 940nm; LED_0603_1608Metric; Digikey 3147-B13V1IR--20C000114U1930CT-ND
J1: 1156861; PinHeader_2x05_P1.27mm_Vertical_SMD; Digikey 277-1156861CT-ND
J2: 0475710001; 47571-0001_MOL; Digikey WM9731CT-ND
J3: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; PARTREV B3; Digikey 2073-USB4105-GF-ACT-ND
J7: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical; Digikey 732-5319-ND
JP5: M50-3530242; PinHeader_1x02_P2.54mm_Vertical; Digikey SAM1112-02-ND (use cheaper part here), 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
L1: 4.7uH; L_0805_2012Metric; Digikey 445-8659-1-ND
Q1: NPN; SOT-23-3; Digikey MMBT3904-FDICT-ND
R1, R5, R16, R20, R21, R22, R24, R26, R27, R30, R31, R32, R33, R34, R35: 10k; R_0603_1608Metric; Digikey 311-10.0KHRCT-ND
R2, R4, R6, R15, R38, R39: 5.1k; R_0603_1608Metric; Digikey 311-5.10KHRCT-ND
R3: NP; R_0603_1608Metric; Digikey NA
R7: 100; R_0603_1608Metric; Digikey 311-100HRCT-ND
R8: 10; R_0603_1608Metric; Digikey 311-10.0HRCT-ND
R10: 1M; R_0603_1608Metric; Digikey 311-1.00MHRCT-ND
R12: 1.69M; R_0603_1608Metric; Digikey 13-RC0603FR-071M69LCT-ND
SW1, SW3, SW4, SW5, SW6, SW7: TS02-66-70-BK-160-LCR-D; SW_PUSH_6mm_H4.3mm; Digikey 2223-TS02-66-70-BK-160-LCR-D-ND
U1: MIC5301; TSOP-5_1.65x3.05mm_P0.95mm; Digikey 576-2840-1-ND
U2: TSOP582xx; Vishay_MINICAST-3Pin; Digikey TSOP58238-ND
U3: ATSAMD21J18A-A; TQFP-64_10x10mm_P0.5mm; Digikey ATSAMD21J18A-AUTCT-ND
U4: ATECC608B-SSHDA; SOIC-8_3.9x4.9mm_P1.27mm; Digikey 150-ATECC608B-SSHDA-TCT-ND
U5: MCP16252; SOT-23-6; Digikey MCP16252T-I/CHCT-ND
U6: ST7735 0.96" 80x160 RGB; Digikey NA
Y2: 049SS2-24.000F20DTLJK; Crystal_SMD_HC49-SD; Digikey XC1001CT-ND

Connections:
/mcu/BUTTON_DOWN: R24.1, U3.62 (PB01)
/mcu/BUTTON_ENTER: R27.2, U3.5 (PB04)
/mcu/BUTTON_LEFT: R22.1, U3.63 (PB02)
/mcu/BUTTON_RIGHT: R30.1, U3.64 (PB03)
/mcu/BUTTON_UP: R26.1, U3.61 (PB00)
/mcu/CS: CON2.P3 (CS), U3.44 (PA23)
/mcu/DEBUG_RX: J7.4, U3.60 (PB31)
/mcu/DEBUG_TX: J7.5, U3.59 (PB30)
/mcu/DISPLAY_BLANK: CON1.P1 (AN), U3.15 (PA06)
/mcu/DISPLAY_CS: CON1.P2 (RST), U3.4 (PA03)
/mcu/DISPLAY_RESET: CON1.P4 (SCK), U3.14 (PA05), U3.36 (PA17)
/mcu/EN_BOOST: R3.2, R35.1, U3.11 (PB08), U5.3 (EN)
/mcu/INT: CON2.P15 (INT), U3.40 (PB17)
/mcu/IR_RX: CON1.P14 (RX), U2.1 (OUT), U3.20 (PA11)
/mcu/IR_RX_ON: CON1.P15 (INT), U2.3 (Vs), U3.19 (PA10)
/mcu/IR_TX: CON1.P13 (TX), R6.1, U3.29 (PA12)
/mcu/LED1: CON2.P1 (AN), D7.2 (A), U3.12 (PB09)
/mcu/LED2: CON2.P2 (RST), D8.2 (A), U3.3 (PA02)
/mcu/LED5: D14.2 (A), U3.50 (PB23)
/mcu/LED6: D13.2 (A), U3.39 (PB16)
/mcu/PWM: CON1.P16 (PWM), CON2.P16 (PWM), D2.2 (A), U3.16 (PA07)
/mcu/RESET: J1.10, R5.2, SW1.2, U3.52 (~RESET)
/mcu/SCL: CON1.P12 (SCL), CON2.P12 (SCL), R39.1, U3.18 (PA09), U4.6 (SCL)
/mcu/SDA: CON1.P11 (SDA), CON2.P11 (SDA), R38.1, U3.17 (PA08), U4.5 (SDA)
/mcu/SD_CLK: J2.P5 (CLK), U3.26 (PB13)
/mcu/SD_DO: J2.P7 (DAT0), U3.25 (PB12)
/mcu/SERCOM1_PAD0: CON2.P6 (MOSI), CON2.P14 (RX), U3.1 (PA00)
/mcu/SERCOM1_PAD1: CON2.P4 (SCK), U3.2 (PA01)
/mcu/SERCOM1_PAD2: CON2.P5 (MISO), CON2.P13 (TX), U3.37 (PA18)
/mcu/SERCOM3_PAD0: CON1.P3 (CS), U3.35 (PA16)
/mcu/SERCOM3_PAD2: CON1.P5 (MISO), U3.41 (PA20)
/mcu/SERCOM3_PAD3: CON1.P6 (MOSI), U3.38 (PA19)
/mcu/SWCLK: J1.4, U3.57 (PA30)
/mcu/SWDIO: J1.2, U3.58 (PA31)
/mcu/SW_1: R16.1, U3.6 (PB05)
/mcu/USB_D+: J3.A6 (DP1), J3.B6 (DP2), U3.46 (PA25)
/mcu/USB_D-: J3.A7 (DN1), J3.B7 (DN2), U3.45 (PA24)
/mcu/VDD_IO: C6.1, C11.1, C14.1, C15.1, C16.1, JP5.1 (A), R8.1, U3.8 (VDDANA), U3.21 (VDDIO), U3.34 (VDDIO), U3.48 (VDDIO), U3.56 (VDDIN)
/mcu/V_RAW: C1.1, D3.1 (K), D5.1 (K), L1.1, R33.1, R35.2, U5.6 (VIN)
GND: BT2.N1, C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, CON1.P8 (GND1), CON1.P9 (GND2), CON2.P8 (GND1), CON2.P9 (GND2), J1.3, J1.5, J1.9, J2.G1 (SHIELD), J2.G2 (SHIELD), J2.G3 (SHIELD), J2.G4 (SHIELD), J2.G5 (SHIELD), J2.P6 (VSS), J3.A1 (GND), J3.A12 (GND__1), J3.S1 (SHELL_GND), J3.S2 (SHELL_GND__1), J3.S3 (SHELL_GND__2), J3.S4 (SHELL_GND__3), J7.1, Q1.2 (E), R1.1, R2.2, R3.1, R4.2, R10.1, R15.2, R16.2, R20.2, R21.2, R31.2, R32.2, R34.2, SW1.1, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, U1.2 (GND), U2.2 (GND), U3.7 (GNDANA), U3.22 (GND), U3.33 (GND), U3.47 (GND), U3.54 (GND), U4.4 (GND), U5.2 (GND)
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.1
unnamed: C7.1, D3.2 (A), U1.5 (VO)
unnamed: D4.2 (A), R7.2
unnamed: D4.1 (K), Q1.3 (C)
unnamed: D7.1 (K), R20.1
unnamed: D8.1 (K), R21.1
unnamed: D13.1 (K), R31.1
unnamed: D14.1 (K), R32.1
unnamed: J2.P3 (CMD), U3.42 (PA21)
unnamed: J3.A5 (CC1), R4.1
unnamed: J3.B5 (CC2), R15.1
unnamed: Q1.1 (B), R6.2
unnamed: R22.2, SW3.1
unnamed: R24.2, SW5.1
unnamed: R26.2, SW4.1
unnamed: R27.1, SW6.1
unnamed: R30.2, SW7.1
unnamed: R33.2, R34.1, U3.13 (PA04)
unnamed: C9.1, U3.31 (PA14), Y2.2
unnamed: C12.1, U3.32 (PA15), Y2.1
unnamed: C13.1, U3.55 (VDDCORE)
unnamed: L1.2, U5.1 (SW)
unnamed: R10.2, R12.2, U5.4 (VFB)
VBAT_1_5V: BT1.P1, D5.2 (A)
VCC: C2.2, C3.1, C4.1, CON1.P7 (3V3), CON2.P7 (3V3), J1.1, J2.P4 (VDD), JP5.2 (B), R5.1, R7.1, R8.2, R12.1, R38.2, R39.2, U4.8 (VCC), U5.5 (VOUT)
V_USB: C5.2, D1.2 (A), J3.A4 (VBUS), J3.A9 (VBUS__1), U1.1 (VI), U1.3 (EN)

Notes on the sheet:
ISSUE: need to set pull down on RX (SERCOM5) in pin config. Without line loading the display (SERCOM3) doesn't correctly receive commands. Reason unknown.
Accept Battery 1.5V or USB through 3.3V Reg Boost Enabled by default: 3.3V MCU can Disabled boost and test V_RAW
SERCOM0
SERCOM5
SERCOM4
Need jumper wire on rev_A board
Select DISPLAY or MIKRO BUS Display: SERCOM.DOPO = 0x1 (MOSI PAD2, SCK PAD3) SERCOM.DIPO = NA PA17 = high z MIKRO : SERCOM.DOPO = 0x02 (MOSI PAD3, SCK PAD1) SERCOM.DIPO = 0x2 (MISO PAD2) PA5 = high z
ISSUE: need to set pull down on the IO. Reason unknown.
KEYPAD
Use INT1V REF
mikroBUS Expansion Port
Authentication
Display
IR Comm
DEBUG SWD Atmel ICE
Debug FTDI
Single AAA
Power

Board: 4 copper layers, 76.2 x 101.6 mm, 72 parts (61 on the bottom side), 67 nets.

## Commit log

2024-07-18 repo setup
2024-07-18 document check in
2024-07-18 remove debug code
2024-07-19 clean up
2024-07-19 convert main to "empty" main
2024-07-22 previous tagged solution only had partial solution, adding full solution
2024-07-22 Updated to exit immediately if prompt not detected and warn to enable admin mode.
2024-07-22 was missing full solution in solution tag. Adding full solution now.
2024-07-22 typo in print outs
2024-07-22 file rename
2024-07-29 Bug fix - IR processing was accidentally dropped. Added back in
2024-07-29 Warning clean up
2024-07-29 revert to entry point
2024-07-29 fix entry point (removed solution code that was included)
2024-08-11 Manual update bug fixes
2024-08-11 fix bad link
2024-10-16 swap entry and solution in head
